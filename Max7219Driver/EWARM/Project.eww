<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Max7219Driver.ewp</path>
  </project>
  <batchBuild />
</workspace>
